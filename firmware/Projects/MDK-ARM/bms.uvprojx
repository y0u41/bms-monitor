# Keil uVision project bms.uvprojx, settings and files
target bms (6240000::V6.24::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00070000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bms +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: -Wno-unused-function -Wno-unused-parameter -Wno-char-subscripts -Wno-missing-braces -Wno-missing-field-initializers -Wno-invalid-source-encoding
  c include: ../../User;../../Drivers/STM32F1xx_HAL_Driver/Inc;../../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../Drivers/CMSIS/Include;../../Drivers/;../../Middlewares/FreeRTOS/include;../../Middlewares/FreeRTOS/portable/GCC/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c gpio.c adc.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart_retarget.c
  group Drivers/BSP
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/DHT11/: dht11.c
    ../../Drivers/BSP/LSENS/: lsens.c
    ../../Drivers/BSP/SHT30/: sht30.c
    ../../Drivers/BSP/AT24CXX/: at24cxx.c
    ../../Drivers/BSP/ESP8266/: esp8266.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/STMFLASH/: stmflash.c
    ../../Drivers/BSP/SOFTI2C/: softi2c.c
    ../../Drivers/BSP/AFE/: afe.c afe_hal_bq76920.c
  group User/App
    ../../User/App/: app_alarm.c app_data.c app_acq.c app_log.c app_main.c app_mqtt.c app_onenet.c app_bus.c app_nvic.c app_protect.c app_tasks.c app_ui.c
  group Readme
    ../../: readme.txt
    ../../User/App/: app_config.h
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/GCC/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
